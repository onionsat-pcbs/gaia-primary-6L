# Repository onionsat-pcbs/gaia-primary-6L

## KiCad design gaia-primary.kicad_pcb

Parts:
C1, C2, C3, C4: 1uF; C_0402_1005Metric
C12, C13: 22pF; C_0402_1005Metric
C17, C18, C19, C20: 100nF; C_0402_1005Metric
D1: LED_Small; LED_0603_1608Metric
J1: Debug Connectors; PinHeader_1x07_P2.54mm_Vertical
J2, J3: Conn_02x10_Odd_Even; Gaia_connector_2_4layer
JP1, JP2, JP3: SolderJumper_3_Open; SolderJumper-3_P2.0mm_Open_TrianglePad1.0x1.5mm
Q1, Q2: BSS138; SOT-23
R1, R2, R3, R4, R8, R9: 10k; R_0402_1005Metric
R5: 100; R_0402_1005Metric
R6: TBA; R_0402_1005Metric
U4: STM32F103C8Tx; LQFP-48_7x7mm_P0.5mm
U10: AP2112K-1.8; SOT-23-5
U11: AP2112K-3.3; SOT-23-5
Y1: Crystal; NX3225GD8MHZSTDCRA3

Connections:
+1V8: C4.1, Q1.1 (G), Q2.1 (G), R1.1, R4.1, U10.5 (VOUT); also elsewhere on the board
+3.3V: C2.1, C17.1, C18.1, C19.1, C20.1, J1.1, R2.1, R3.1, R9.2, U4.9 (VDDA), U4.24 (VDD), U4.36 (VDD), U4.48 (VDD), U11.5 (VOUT); also elsewhere on the board
/DEBUG_NRST: J1.6, R9.1, U4.7 (NRST)
/DEBUG_SWD_CLK: J1.2, U4.37 (PA14)
/DEBUG_SWD_IO: J1.3, U4.34 (PA13)
/DEBUG_USART_RX: J1.4, U4.31 (PA10)
/DEBUG_USART_TX: J1.5, U4.30 (PA9)
/GLOBAL_SCL: JP2.2 (C), U4.42 (PB6)
/GLOBAL_SDA: JP3.2 (C), U4.43 (PB7)
/LOCAL_SCL: Q1.3 (D), R2.2, U4.21 (PB10); also elsewhere on the board
/LOCAL_SDA: Q2.3 (D), R3.2, U4.22 (PB11); also elsewhere on the board
/READY1: U4.11 (PA1); also elsewhere on the board
/READY2: U4.12 (PA2); also elsewhere on the board
/SCL_1V8: Q1.2 (S), R1.2; also elsewhere on the board
/SDA_1V8: Q2.2 (S), R4.2; also elsewhere on the board
/SPI1_CS1: U4.13 (PA3); also elsewhere on the board
/SPI1_CS2: U4.14 (PA4); also elsewhere on the board
/SPI1_MISO: U4.16 (PA6); also elsewhere on the board
/SPI1_MOSI: U4.17 (PA7); also elsewhere on the board
/SPI1_SCK: U4.15 (PA5); also elsewhere on the board
/VOUT_A1: J3.1, J3.2, JP1.1 (A)
/VOUT_B1: J3.7, J3.8, JP1.3 (B)
GND: C1.2, C2.2, C3.2, C4.2, C12.2, C13.1, C17.2, C18.2, C19.2, C20.2, J1.7, J2.7, J2.9, J2.17, J2.18, J2.19, J2.20, J3.13, J3.14, J3.15, J3.16, R6.1, R8.1, U4.8 (VSSA), U4.23 (VSS), U4.35 (VSS), U4.47 (VSS), U10.2 (GND), U11.2 (GND); also elsewhere on the board
I2C_1_SCL: J2.4, JP2.3 (B)
I2C_1_SDA: J2.2, JP3.3 (B)
I2C_2_SCL: J2.3, JP2.1 (A)
I2C_2_SDA: J2.1, JP3.1 (A)
unnamed: C12.1, R5.1, Y1.1
unnamed: D1.2 (A), U4.25 (PB12)
unnamed: D1.1 (K), R6.2
unnamed: R8.2, U4.44 (BOOT0)
unnamed: C13.2, U4.5 (PD0), Y1.2
unnamed: R5.2, U4.6 (PD1)
VCC: C1.1, C3.1, JP1.2 (C), U10.1 (VIN), U10.3 (EN), U11.1 (VIN), U11.3 (EN)

Notes on the sheet:
MCU
I^{2}C Level Shifters
A/B Jumpers
LDO Voltage Regulators
Connectors

Parts:
C5, C6, C8, C9, C10, C11, C14, C15: 100nF; C_0402_1005Metric
C7, C16: 10nF; C_0402_1005Metric
R7, R13, R15, R16: 10k; R_0402_1005Metric
R10, R11: 4kOhm 0,1%; R_1206_3216Metric
TH3, TH4: Pt1000; yageo_m1020
U5, U7: MAX31865xTP; TQFN-20-1EP_5x5mm_P0.65mm_EP3.1x3.1mm
U6, U9: BME680/BME690; Bosch_LGA-8_3x3mm_P0.8mm_ClockwisePinNumbering

Connections:
+3.3V: C5.2, C6.1, C8.2, C9.2, C10.2, C11.2, C14.2, C15.1, R7.1, R13.1, R15.1, R16.1, U5.19 (DVDD), U5.20 (VDD), U6.2 (CSB), U6.6 (VDDIO), U6.8 (VDD), U7.19 (DVDD), U7.20 (VDD), U9.2 (CSB), U9.5 (SDO), U9.6 (VDDIO), U9.8 (VDD); also elsewhere on the board
/LOCAL_SCL: R7.2, R13.2, U6.4 (SCK), U9.4 (SCK); also elsewhere on the board
/LOCAL_SDA: R15.2, R16.2, U6.3 (SDI), U9.3 (SDI); also elsewhere on the board
/READY1: U5.18 (~DRDY); also elsewhere on the board
/READY2: U7.18 (~DRDY); also elsewhere on the board
/SPI1_CS1: U5.13 (~CS); also elsewhere on the board
/SPI1_CS2: U7.13 (~CS); also elsewhere on the board
/SPI1_MISO: U5.14 (SDO), U7.14 (SDO); also elsewhere on the board
/SPI1_MOSI: U5.11 (SDI), U7.11 (SDI); also elsewhere on the board
/SPI1_SCK: U5.12 (SCLK), U7.12 (SCLK); also elsewhere on the board
GND: C5.1, C6.2, C8.1, C9.1, C10.1, C11.1, C14.1, C15.2, U5.6 (FORCE2), U5.10 (GND), U5.15 (DGND), U5.16 (GND), U5.21 (GND), U6.1 (GND), U6.5 (SDO), U6.7 (GND), U7.6 (FORCE2), U7.10 (GND), U7.15 (DGND), U7.16 (GND), U7.21 (GND), U9.1 (GND), U9.7 (GND); also elsewhere on the board
unnamed: R10.1, U5.1 (BIAS), U5.2 (REFIN+)
unnamed: C7.1, TH3.1, U5.5 (FORCE+), U5.7 (RTDIN+)
unnamed: C7.2, TH3.2, U5.8 (RTDIN-), U5.9 (FORCE-)
unnamed: R10.2, U5.3 (REFIN-), U5.4 (ISENSOR)
unnamed: R11.1, U7.1 (BIAS), U7.2 (REFIN+)
unnamed: C16.1, TH4.1, U7.5 (FORCE+), U7.7 (RTDIN+)
unnamed: C16.2, TH4.2, U7.8 (RTDIN-), U7.9 (FORCE-)
unnamed: R11.2, U7.3 (REFIN-), U7.4 (ISENSOR)

Notes on the sheet:
BME680/690 nr 1. (0x76)
BME680/690 nr 2. (0x77)
Precision Temperature Sensor (RTD) nr 1.
Precision Temperature Sensor (RTD) nr 2.

Parts:
C23, C24, C25, C26, C27, C28, C29, C30: 100nF; C_0402_1005Metric
IC2: ADXL375BCCZ; CC-14-1; Mouser Part Number 584-ADXL375BCCZ
R12, R14: 10k; R_0402_1005Metric
U12, U13: ICM-20948; InvenSense_QFN-24_3x3mm_P0.4mm

Connections:
+1V8: C25.2, C26.2, C28.2, C29.2, U12.8 (VDDIO), U12.9 (SDO/AD0), U12.13 (VDD), U13.8 (VDDIO), U13.13 (VDD); also elsewhere on the board
+3.3V: C23.1, C24.1, IC2.1 (VDD_I/O), IC2.6 (VS), IC2.7 (~CS), R12.1, R14.1; also elsewhere on the board
/LOCAL_SCL: IC2.14 (SCL/SCLK), R12.2; also elsewhere on the board
/LOCAL_SDA: IC2.13 (SDA/DO/SDIO), R14.2; also elsewhere on the board
/SCL_1V8: U12.23 (SCL/SCLK), U13.23 (SCL/SCLK); also elsewhere on the board
/SDA_1V8: U12.24 (SDA/SDI), U13.24 (SDA/SDI); also elsewhere on the board
GND: C23.2, C24.2, C25.1, C26.1, C27.1, C28.1, C29.1, C30.1, IC2.2 (GND_1), IC2.4 (GND_2), IC2.5 (GND_3), IC2.12 (SDO/ALT_ADDRESS), U12.18 (GND), U12.20 (GND), U13.9 (SDO/AD0), U13.18 (GND), U13.20 (GND); also elsewhere on the board
unnamed: C27.2, U12.10 (REGOUT)
unnamed: C30.2, U13.10 (REGOUT)

Notes on the sheet:
9DoF IMU nr 1. (0x69)
9DoF IMU nr 2. (0x68)
200G Accelerometer (0x54)

Board: 6 copper layers, 50.0 x 50.0 mm, 66 parts (18 on the bottom side), 44 nets.

## Commit log

2025-09-10 6layer create
2025-09-15 routing to 6L + generating production files
2025-09-15 routing fixes
2025-09-18 adding orientation star
2025-09-18 creating schematic pdf
2025-09-18 generating production files
2025-09-18 adding camera bott to stencil
2026-01-03 3d models
